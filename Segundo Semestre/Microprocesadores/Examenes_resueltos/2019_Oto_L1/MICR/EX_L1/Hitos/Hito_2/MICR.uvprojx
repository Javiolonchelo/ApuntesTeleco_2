# Keil uVision project MICR.uvprojx, settings and files
target mbed_LPC1768 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.5.0
  cpu: CPUTYPE("Cortex-M3")
  output: mbed_LPC1768
  AfterMake: fromelf --bin -o "$L@L.bin" "!L"
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: TARGET_MBED_LPC1768 DEVICE_RTC=1 DEVICE_SLEEP=1 TOOLCHAIN_object TOOLCHAIN_ARM_STD DEVICE_SEMIHOST=1 FEATURE_LWIP=1 __ASSERT_MSG TARGET_LPC1768 TARGET_RELEASE DEVICE_PORTINOUT=1 __CORTEX_M3 DEVICE_DEBUG_AWARENESS=1 TARGET_M3 DEVICE_CAN=1 DEVICE_PORTOUT=1 DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 ARM_MATH_CM3 TARGET_LIKE_CORTEX_M3 DEVICE_ANALOGIN=1 DEVICE_PORTIN=1 TARGET_CORTEX_M DEVICE_ERROR_PATTERN=1 MBED_BUILD_TIMESTAMP=1497285907.81 DEVICE_ETHERNET=1 TARGET_LPCTarget DEVICE_I2C=1 TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 TARGET_UVISOR_UNSUPPORTED DEVICE_PWMOUT=1 TARGET_LIKE_MBED DEVICE_SPI=1 __MBED__=1 DEVICE_SPISLAVE=1 DEVICE_SERIAL_FC=1 DEVICE_LOCALFILESYSTEM=1 DEVICE_SERIAL=1 TARGET_LPC176X DEVICE_I2CSLAVE=1 __CMSIS_RTOS TARGET_NXP __MBED_CMSIS_RTOS_CM
  c misc: --cpu=Cortex-M3 -c --no_depend_system_headers --apcs=interwork --no_rtti --diag_suppress=951,1361 --preinclude=../../../mbed/mbed_config_lpc1768.h
  c include: .;../../../mbed/.;../../../mbed/TARGET_LPC1768;../../../mbed/TARGET_LPC1768/TARGET_NXP;../../../mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X;../../../mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768;../../../mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device;../../../mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD;../../../mbed/drivers;../../../mbed/hal;../../../mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ../../../mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/LPC1768.sct
  group mbed_common
    ../../../mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h Stream.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    ../../../mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    ../../../mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h CThunkBase.h DeepSleepLock.h FileSystemHandle.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_crash_data_offsets.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h toolchain.h Transaction.h wait_api.h
  group mbed_LPC1768
    ../../../mbed/TARGET_LPC1768/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_ca.h core_ca_mmu.h core_ca9.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cm23.h core_cm33.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h mbed_cmsis_conf.h mpu_armv7.h mpu_armv8.h RTE_Components.h tz_context.h
    ../../../mbed/TARGET_LPC1768/TARGET_NXP/: mbed_rtx.h
    ../../../mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/: gpio_object.h objects.h PeripheralNames.h PortNames.h
    ../../../mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/device/: cmsis.h cmsis_nvic.h LPC17xx.h system_LPC17xx.h
    ../../../mbed/TARGET_LPC1768/TARGET_NXP/TARGET_LPC176X/TARGET_MBED_LPC1768/: device.h PinNames.h reserved_pins.h
    ../../../mbed/TARGET_LPC1768/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o CRP.o ethernet_api.o flash_api.o gpio_api.o gpio_irq_api.o i2c_api.o mbed_board.o mbed_retarget.o mbed_tz_context.o pinmap.o port_api.o pwmout_api.o rtc_api.o serial_api.o sleep.o spi_api.o startup_LPC17xx.o sys.o system_LPC17xx.o us_ticker.o mbed.ar
  group mbed_NUCLEO_L432KC
    ../../../mbed/TARGET_NUCLEO_L432KC/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_ca.h core_ca_mmu.h core_ca9.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cm23.h core_cm33.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h mbed_cmsis_conf.h mpu_armv7.h mpu_armv8.h RTE_Components.h tz_context.h
    ../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/: gpio_object.h mbed_rtx.h nvic_addr.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h serial_api_hal.h stm32_assert.h
    ../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h spi_device.h
    ../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/device/: stm32_hal_legacy.h stm32l4xx_hal.h stm32l4xx_hal_adc.h stm32l4xx_hal_adc_ex.h stm32l4xx_hal_can.h stm32l4xx_hal_can_legacy.h stm32l4xx_hal_comp.h stm32l4xx_hal_conf.h stm32l4xx_hal_cortex.h stm32l4xx_hal_crc.h stm32l4xx_hal_crc_ex.h stm32l4xx_hal_cryp.h stm32l4xx_hal_cryp_ex.h stm32l4xx_hal_dac.h stm32l4xx_hal_dac_ex.h stm32l4xx_hal_dcmi.h stm32l4xx_hal_def.h stm32l4xx_hal_dfsdm.h stm32l4xx_hal_dfsdm_ex.h stm32l4xx_hal_dma.h stm32l4xx_hal_dma_ex.h stm32l4xx_hal_dma2d.h stm32l4xx_hal_dsi.h stm32l4xx_hal_firewall.h stm32l4xx_hal_flash.h stm32l4xx_hal_flash_ex.h stm32l4xx_hal_flash_ramfunc.h stm32l4xx_hal_gfxmmu.h stm32l4xx_hal_gpio.h stm32l4xx_hal_gpio_ex.h stm32l4xx_hal_hash.h stm32l4xx_hal_hash_ex.h stm32l4xx_hal_hcd.h stm32l4xx_hal_i2c.h stm32l4xx_hal_i2c_ex.h stm32l4xx_hal_irda.h stm32l4xx_hal_irda_ex.h stm32l4xx_hal_iwdg.h stm32l4xx_hal_lcd.h stm32l4xx_hal_lptim.h stm32l4xx_hal_ltdc.h stm32l4xx_hal_ltdc_ex.h stm32l4xx_hal_nand.h stm32l4xx_hal_nor.h stm32l4xx_hal_opamp.h stm32l4xx_hal_opamp_ex.h stm32l4xx_hal_ospi.h stm32l4xx_hal_pcd.h stm32l4xx_hal_pcd_ex.h stm32l4xx_hal_pwr.h stm32l4xx_hal_pwr_ex.h stm32l4xx_hal_qspi.h stm32l4xx_hal_rcc.h stm32l4xx_hal_rcc_ex.h stm32l4xx_hal_rng.h stm32l4xx_hal_rtc.h stm32l4xx_hal_rtc_ex.h stm32l4xx_hal_sai.h stm32l4xx_hal_sai_ex.h stm32l4xx_hal_sd.h stm32l4xx_hal_sd_ex.h stm32l4xx_hal_smartcard.h stm32l4xx_hal_smartcard_ex.h stm32l4xx_hal_smbus.h stm32l4xx_hal_spi.h stm32l4xx_hal_spi_ex.h stm32l4xx_hal_sram.h stm32l4xx_hal_swpmi.h stm32l4xx_hal_tim.h stm32l4xx_hal_tim_ex.h stm32l4xx_hal_tsc.h stm32l4xx_hal_uart.h stm32l4xx_hal_uart_ex.h stm32l4xx_hal_usart.h stm32l4xx_hal_usart_ex.h stm32l4xx_hal_wwdg.h stm32l4xx_ll_adc.h stm32l4xx_ll_bus.h stm32l4xx_ll_comp.h stm32l4xx_ll_cortex.h stm32l4xx_ll_crc.h stm32l4xx_ll_crs.h stm32l4xx_ll_dac.h stm32l4xx_ll_dma.h stm32l4xx_ll_dma2d.h stm32l4xx_ll_dmamux.h stm32l4xx_ll_exti.h stm32l4xx_ll_fmc.h stm32l4xx_ll_gpio.h stm32l4xx_ll_i2c.h stm32l4xx_ll_iwdg.h stm32l4xx_ll_lptim.h stm32l4xx_ll_lpuart.h stm32l4xx_ll_opamp.h stm32l4xx_ll_pwr.h stm32l4xx_ll_rcc.h stm32l4xx_ll_rng.h stm32l4xx_ll_rtc.h stm32l4xx_ll_sdmmc.h stm32l4xx_ll_spi.h stm32l4xx_ll_swpmi.h stm32l4xx_ll_system.h stm32l4xx_ll_tim.h stm32l4xx_ll_usart.h stm32l4xx_ll_usb.h stm32l4xx_ll_utils.h stm32l4xx_ll_wwdg.h
    ../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/: objects.h
    ../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32l4xx.h stm32l432xx.h system_stm32l4xx.h us_ticker_data.h
    ../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TARGET_NUCLEO_L432KC/: PeripheralNames.h PinNames.h
    ../../../mbed/TARGET_NUCLEO_L432KC/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o flash_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o l4_retarget.o lp_ticker.o mbed_board.o mbed_crc_api.o mbed_overrides.o mbed_retarget.o mbed_tz_context.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32l432xx.o stm_spi_api.o stm32l4xx_hal.o stm32l4xx_hal_adc.o stm32l4xx_hal_adc_ex.o stm32l4xx_hal_can.o stm32l4xx_hal_comp.o stm32l4xx_hal_cortex.o stm32l4xx_hal_crc.o stm32l4xx_hal_crc_ex.o stm32l4xx_hal_cryp.o stm32l4xx_hal_cryp_ex.o stm32l4xx_hal_dac.o stm32l4xx_hal_dac_ex.o stm32l4xx_hal_dcmi.o stm32l4xx_hal_dfsdm.o stm32l4xx_hal_dfsdm_ex.o stm32l4xx_hal_dma.o stm32l4xx_hal_dma_ex.o stm32l4xx_hal_dma2d.o stm32l4xx_hal_dsi.o stm32l4xx_hal_firewall.o stm32l4xx_hal_flash.o stm32l4xx_hal_flash_ex.o stm32l4xx_hal_flash_ramfunc.o stm32l4xx_hal_gfxmmu.o stm32l4xx_hal_gpio.o stm32l4xx_hal_hash.o stm32l4xx_hal_hash_ex.o stm32l4xx_hal_hcd.o stm32l4xx_hal_i2c.o stm32l4xx_hal_i2c_ex.o stm32l4xx_hal_irda.o stm32l4xx_hal_iwdg.o stm32l4xx_hal_lcd.o stm32l4xx_hal_lptim.o stm32l4xx_hal_ltdc.o stm32l4xx_hal_ltdc_ex.o stm32l4xx_hal_msp_template.o stm32l4xx_hal_nand.o stm32l4xx_hal_nor.o stm32l4xx_hal_opamp.o stm32l4xx_hal_opamp_ex.o stm32l4xx_hal_ospi.o stm32l4xx_hal_pcd.o stm32l4xx_hal_pcd_ex.o stm32l4xx_hal_pwr.o stm32l4xx_hal_pwr_ex.o stm32l4xx_hal_qspi.o stm32l4xx_hal_rcc.o stm32l4xx_hal_rcc_ex.o stm32l4xx_hal_rng.o stm32l4xx_hal_rtc.o stm32l4xx_hal_rtc_ex.o stm32l4xx_hal_sai.o stm32l4xx_hal_sai_ex.o stm32l4xx_hal_sd.o stm32l4xx_hal_sd_ex.o stm32l4xx_hal_smartcard.o stm32l4xx_hal_smartcard_ex.o stm32l4xx_hal_smbus.o stm32l4xx_hal_spi.o stm32l4xx_hal_spi_ex.o stm32l4xx_hal_sram.o stm32l4xx_hal_swpmi.o stm32l4xx_hal_tim.o stm32l4xx_hal_tim_ex.o stm32l4xx_hal_tsc.o stm32l4xx_hal_uart.o stm32l4xx_hal_uart_ex.o stm32l4xx_hal_usart.o stm32l4xx_hal_usart_ex.o stm32l4xx_hal_wwdg.o stm32l4xx_ll_adc.o stm32l4xx_ll_comp.o stm32l4xx_ll_crc.o stm32l4xx_ll_crs.o stm32l4xx_ll_dac.o stm32l4xx_ll_dma.o stm32l4xx_ll_dma2d.o stm32l4xx_ll_exti.o stm32l4xx_ll_fmc.o stm32l4xx_ll_gpio.o stm32l4xx_ll_i2c.o stm32l4xx_ll_lptim.o stm32l4xx_ll_lpuart.o stm32l4xx_ll_opamp.o stm32l4xx_ll_pwr.o stm32l4xx_ll_rcc.o stm32l4xx_ll_rng.o stm32l4xx_ll_rtc.o stm32l4xx_ll_sdmmc.o stm32l4xx_ll_spi.o stm32l4xx_ll_swpmi.o stm32l4xx_ll_tim.o stm32l4xx_ll_usart.o stm32l4xx_ll_usb.o stm32l4xx_ll_utils.o sys.o system_stm32l4xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o mbed.ar
  group sw_tick_serial
    ../../../sw_tick_serial/: sw_tick_serial_LPC1768.lib sw_tick_serial_NUCLEO_L432KC.lib
  group to_7seg
    ../../../to_7seg/: to_7seg_LPC1768.lib to_7seg_NUCLEO_L432KC.lib
  group C++ Sources
    ./: main.cpp
    ./: pinout.h sw_tick_serial.h to_7seg.h
target mbed_NUCLEO_L432KC (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mbed_NUCLEO_L432KC
  AfterMake: fromelf --bin -o "$L@L.bin" "!L"
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: TARGET_NUCLEO_L432KC DEVICE_RTC=1 DEVICE_SLEEP=1 TOOLCHAIN_object TOOLCHAIN_ARM_STD TARGET_STM32L432KC __ASSERT_MSG TARGET_RELEASE DEVICE_PORTINOUT=1 DEVICE_I2C_ASYNCH=1 TARGET_FF_ARDUINO TARGET_RTOS_M4_M7 DEVICE_CAN=1 DEVICE_PORTOUT=1 DEVICE_STDIO_MESSAGES=1 DEVICE_ANALOGOUT=1 DEVICE_SERIAL_FC=1 DEVICE_SERIAL=1 DEVICE_ANALOGIN=1 TARGET_LIKE_CORTEX_M4 ARM_MATH_CM4 TARGET_CORTEX_M DEVICE_I2C=1 __CORTEX_M4 DEVICE_LOWPOWERTIMER=1 TARGET_STM TOOLCHAIN_ARM DEVICE_INTERRUPTIN=1 TARGET_UVISOR_UNSUPPORTED DEVICE_PWMOUT=1 TARGET_LIKE_MBED DEVICE_TRNG=1 DEVICE_SPI=1 __MBED__=1 MBED_BUILD_TIMESTAMP=1497275374.01 DEVICE_SPISLAVE=1 TARGET_STM32L4 TARGET_STM32L432xC DEVICE_PORTIN=1 TARGET_M4 __FPU_PRESENT=1 DEVICE_I2CSLAVE=1 __CMSIS_RTOS DEVICE_SPI_ASYNCH=1 TRANSACTION_QUEUE_SIZE_SPI=2 __MBED_CMSIS_RTOS_CM
  c misc: --cpu=Cortex-M4.fp -c --no_depend_system_headers --apcs=interwork --no_rtti --diag_suppress=951,1361 --preinclude=../../../mbed/mbed_config_nucleo_l432kc.h
  c include: .;../../../mbed/.;../../../mbed/TARGET_NUCLEO_L432KC;../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM;../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4;../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC;../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/TARGET_NUCLEO_L432KC;../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/TARGET_STM32L432xC/device;../../../mbed/TARGET_NUCLEO_L432KC/TARGET_STM/TARGET_STM32L4/device;../../../mbed/TARGET_NUCLEO_L432KC/TOOLCHAIN_ARM_STD;../../../mbed/drivers;../../../mbed/hal;../../../mbed/platform
  asm misc: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: ..\..\..\mbed\TARGET_NUCLEO_L432KC\TOOLCHAIN_ARM_STD\stm32l432xx.sct
